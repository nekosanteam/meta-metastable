require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
SRC_URI[sha256sum] = "98dce69077c35cffca799dcdbbd32a02242aad6b0950eb931936bb2ef69f0926"
