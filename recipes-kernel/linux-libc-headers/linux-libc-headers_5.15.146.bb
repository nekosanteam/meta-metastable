require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
SRC_URI[sha256sum] = "5a807a5fa2a80ada957d8079681dfb5cc196ec26f43244d1c8a4fd7af592d192"
